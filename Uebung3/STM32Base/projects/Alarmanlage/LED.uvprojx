# Keil uVision project LED.uvprojx, settings and files
target APUS (6240000::V6.24::ARMCLANG)
  device: STM32F072VBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LED
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c include: .\;..\..\system\cmsis;..\..\system\stm32f0-stdperiph;..\..\system\board;..\..\system\utils
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group stm32f0-stdperiph
    ../../system/stm32f0-stdperiph/: stm32f0xx_gpio.c stm32f0xx_rcc.c
  group cmsis
    ../../system/cmsis/: system_stm32f0xx.c startup_stm32f072.s
  group app
    ./: stm32f0xx_conf.h main.c
  group utils
    ../../system/utils/: sysdelay.c
  group board
    ../../system/board/: board_button.h board_led.c board_led.h board_button.c
